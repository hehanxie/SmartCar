<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>RAM</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>FLASH</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>BOOT</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>app</name>
    <file>
      <name>$PROJ_DIR$\..\app\k60_card.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\app\Test.c</name>
    </file>
  </group>
  <group>
    <name>lib</name>
    <group>
      <name>common</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\alloc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\assert.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\assert.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\CameraScan.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\CameraScan.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\common.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\DirectionControl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\DirectionControl.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\include.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\init.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\io.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\io.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\printf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\queue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\queue.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\relocate.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\relocate.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\ScreenMenu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\ScreenMenu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\SpeedControl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\SpeedControl.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\stdlib.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\stdlib.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\uif.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\common\uif.h</name>
      </file>
    </group>
    <group>
      <name>CPU</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\CPU\startup_K60D10.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\CPU\system_MK60.c</name>
      </file>
    </group>
    <group>
      <name>LPLD</name>
      <group>
        <name>DEV</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\DEV\DEV_SCCB.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\DEV\DEV_SCCB.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\DEV\Global_var.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\DEV\Global_var.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\DEV\key.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\DEV\key.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\DEV\LQ12864.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\DEV\LQ12864.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\DEV\OV7725.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\DEV\OV7725.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\DEV\OV7725_REG.h</name>
        </file>
      </group>
      <group>
        <name>HW</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_ADC.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_ADC.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_DMA.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_DMA.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_FTM.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_FTM.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_GPIO.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_GPIO.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_MCG.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_MCG.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_PIT.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_PIT.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_UART.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\lib\LPLD\HW\HW_UART.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\LPLD\LPLD_Drivers.h</name>
      </file>
    </group>
  </group>
</project>


